# Keil uVision project MM32_Test.uvprojx, settings and files
target MM32_Test (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MM32W373PSB MindMotion
  pack: MindMotion.MM32W3xxB_DFP.1.0.7
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MM32_Test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\BSP\adc;..\BSP\delay;..\BSP\softwareI2C;..\BSP\SPI;..\BSP\sys;..\BSP\tim;..\BSP\uart;..\Hardware\BUZZER;..\Hardware\EEPROM;..\Hardware\FLASH;..\Hardware\LED;..\Hardware\KEY;..\Libraries\CMSIS\KEIL_CORE;..\Libraries\MM32L3xx\HAL_lib\inc;..\Libraries\MM32L3xx\Include;..\Libraries\MM32L3xx\Source\KEIL_StartAsm;..\Libraries\MM32L3xx\HAL_lib\src;..\Libraries\MM32L3xx\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Libraries/MM32L3xx/Source/: system_MM32L3xx.c
    ../Libraries/MM32L3xx/Source/KEIL_StartAsm/: startup_MM32L3xx.s
  group Hal
    ../Libraries/MM32L3xx/HAL_lib/src/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_crc.c HAL_dac.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group App
    ../APP/: main.c
  group BSP
    ../BSP/adc/: adc.c
    ../BSP/delay/: delay.c
    ../BSP/softwareI2C/: softwarei2c.c
    ../BSP/SPI/: spi.c
    ../BSP/sys/: sys.c
    ../BSP/tim/: tim.c
    ../BSP/uart/: uart.c
  group Hardware
    ../Hardware/BUZZER/: beep.c
    ../Hardware/EEPROM/: eeprom.c
    ../Hardware/FLASH/: sflash.c
    ../Hardware/KEY/: key.c
    ../Hardware/LED/: led.c
